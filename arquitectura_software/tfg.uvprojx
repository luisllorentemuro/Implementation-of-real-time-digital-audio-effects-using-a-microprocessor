# Keil uVision project tfg.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: S6E2CCAJ0A Cypress
  pack: Keil.FM4_DFP.1.6.0
  cpu: IRAM(0x1FFD0000,0x30000) IRAM2(0x20038000,0x10000) IROM(0x00000000,0x200000) IROM2(0x00406000,0xA000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab5
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: _LAB_DEBUG_=1
  c include: HAL_FM4_v2\includes;.\src
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1ffd0000 size 0x30000
  memory RVCT10: RAM 0x20038000 size 0x10000
  group HAL_FM4
    HAL_FM4_v2/src/: FM4_leds_sw.c FM4_WM8731.c HAL_FM4_dtimer.c HAL_FM4_gpio.c HAL_FM4_i2c.c HAL_FM4_i2s.c pulsaciones.c
    ./HAL_FM4_v2/src/: HAL_SysTick.c
  group src
    ./src/: efecto_atenuacion.c efecto_atenuacion.h efecto_atenuacion_int.h efecto_distortion.c efecto_distortion.h efecto_distortion_int.h efecto_fuzz.c efecto_fuzz.h efecto_fuzz_int.h efecto_mute.c efecto_mute.h efecto_mute_int.h efecto_none.c efecto_none.h efecto_none_int.h efecto_overdrive.c efecto_overdrive.h efecto_overdrive_int.h efectos.c efectos.h efectos_int.h fixedpoint.c fixedpoint.h ISR.c main.c main.h efecto_delay.c efecto_delay.h efecto_delay_int.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
